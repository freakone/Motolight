# Keil uVision project motolight.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: motolight
  c flags: Optim=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c i2c.c stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_conf.h
software components: CMSIS:CORE 3.30.0, Device:Startup 1.5.0
